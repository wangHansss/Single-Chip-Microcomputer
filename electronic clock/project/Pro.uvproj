# Keil uVision project Pro.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Pro +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: STARTUP.A51
    ../src/: main.c
  group library
    ../src/: ds1302.c onewire.c
  group system
    ../src/: common.c key.c smg.c
